## net/core/Kconfig
```kconfig
#
# Core configuration
#

config NETDEVICES_LB
	bool "Load balancing of connection buckets"
```
